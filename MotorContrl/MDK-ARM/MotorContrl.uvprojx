# Keil uVision project MotorContrl.uvprojx, settings and files
target MotorContrl (6240000::V6.24::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MotorContrl +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Inc
    ../Inc/: app_aux_output.h app_led.h app_light.h app_limit.h app_motion.h app_protocol.h app_scheduler.h app_types.h config.h gpio.h i2c.h led.h main.h mcp4728.h spi.h stm32f1xx_hal_conf.h stm32f1xx_it.h system_clock.h tim.h tmc5160.h usart.h
  group Src
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_clock.c system_stm32f1xx.c
  group Drivers/Board
    ../Drivers/Board/: gpio.c i2c.c led.c mcp4728.c spi.c tim.c tmc5160.c usart.c
  group APPs
    ../APPs/: app_aux_output.c app_led.c app_light.c app_limit.c app_motion.c app_protocol.c app_scheduler.c
software components: CMSIS:CORE 6.2.0
